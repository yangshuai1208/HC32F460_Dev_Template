# Keil uVision project HC32F460_Template.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: HC32F460JETA HDSC
  pack: HDSC.HC32F460.1.0.11
  cpu: IRAM(0x1FFF8000,0x2F000) IRAM2(0x200F0000,0x1000) IROM(0x00000000,0x80000) IROM2(0x03000C00,0x003FC) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: HC32F460_Template
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\Core;..\Drivers\HC32_DDL\inc;..\Drivers\HC32_DDL\common
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x3000c00 size 0x3fc
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  group Core
    ../Core/: main.c system_hc32f46x.c
  group Drivers
    ../Drivers/HC32_DDL/src/: hc32f46x_gpio.c hc32f46x_clk.c hc32f46x_utility.c
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.0
