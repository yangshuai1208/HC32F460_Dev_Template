# Keil uVision project template.uvprojx, settings and files
target template_Debug (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: HC32F460JETA HDSC
  pack: HDSC.HC32F460.1.0.11
  cpu: IRAM(0x1FFF8000,0x2F000) IRAM2(0x200F0000,0x1000) IROM(0x00000000,0x80000) IROM2(0x03000C00,0x003FC) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: DVT3.3-t.hex +hex
  AfterMake: fromelf --bin !L --output hc32f46x_app.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: __DEBUG,HC32F46x,USE_DEVICE_DRIVER_LIB
  c misc: --diag_suppress=186,66
  c include: ..\..\..\mcu\common;..\source;..\source\freertos\inc;..\source\app\inc;..\..\..\driver\inc;..\source\matlab\inc
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x3000c00 size 0x3fc
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32f46x.s
    ../../../mcu/common/: system_hc32f46x.c
  group source
    ../source/: main.c ddl_config.h
    ../source/app/src/: app_gpio.c app_adc.c app_param.c app_uart.c app.c app_wdt.c ntc_temperature.c app_pvdf.c app_modbus.c
  group driver
    ../../../driver/src/: hc32f46x_utility.c hc32f46x_gpio.c hc32f46x_clk.c hc32f46x_efm.c hc32f46x_usart.c hc32f46x_interrupts.c hc32f46x_pwc.c hc32f46x_dmac.c hc32f46x_timer6.c hc32f46x_adc.c hc32f46x_exint_nmi_swi.c hc32f46x_wdt.c
  group freertos
    ../source/freertos/src/: croutine.c event_groups.c heap_4.c list.c port.c queue.c tasks.c timers.c
  group matlab
    ../source/matlab/src/: rt_nonfinite.c rtGetInf.c rtGetNaN.c uvtest.c
target template_Release (5060020::V5.06 (build 20)::ARMCC)
  device: HC32F460PETB HDSC
  pack: HDSC.HC32F460.1.0.11
  cpu: IROM(0x00000000,0x80000) IROM2(0x03000C00,0x3FC) IRAM2(0x200F0000,0x1000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1
  c define: HC32F46x,USE_DEVICE_DRIVER_LIB
  c misc: --diag_suppress=186,66
  c include: ..\..\..\mcu\common;..\source;..\..\..\driver\inc;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x7e000
  memory RVCT5: ROM 0x3000c00 size 0x3fc
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  link misc: --keep=*Handler
software components: CMSIS:CORE 5.5.0
